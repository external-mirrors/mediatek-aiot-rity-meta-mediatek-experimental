
PACKAGECONFIG:append = " vulkan "
